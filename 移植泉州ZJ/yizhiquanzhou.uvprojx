# Keil uVision project yizhiquanzhou.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: yizhiquanzhou +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\Quanzhou;.\Lib\CMSIS\CM3\CoreSupport;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\User;.\Quanzhou\usart;.\Quanzhou\jidianqi;.\2416;.\Quanzhou\watchdog;.\Quanzhou\bianpingqi;.\Quanzhou\压针;.\Quanzhou\bianmaqi;.\Quanzhou\bianpingqi;.\Quanzhou\delay;.\Quanzhou\delay;.\Quanzhou\压针;.\Quanzhou\yazhen;.\Quanzhou\bsp_usart;.\Quanzhou\bsp_usart;.\system;.\init;.\步进电机;.\中断;.\中断;.\Quanzhou
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Core
    ./Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ./User/: main.c stm32f10x_it.c
  group LIB
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_pwr.c
  group Quanzhou
    ./Quanzhou/: bsp_SysTick.c PVD.c bsp_Beep.c bsp_key.c
    ./Quanzhou/watchdog/: wdt.c
    ./Quanzhou/jidianqi/: bsp_16jidianqi.c
    ./Quanzhou/bianpingqi/: bsp_bianpingqi.c
    ./Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c
    ./Quanzhou/delay/: delay.c
    ./Quanzhou/bianmaqi/: encoder1.c
    ./Quanzhou/bsp_usart/: bsp_usartx.c
  group Readme
    ./Readme/: 压针.txt 16路继电器.txt 开发环境说明.txt 代码.txt 重要变量说明.txt 版本说明.txt
  group 2416
    ./2416/: appBase.c communication.c 2440lib.c
  group system
    ./system/: qz_system.c
  group init
    ./init/: init.c
  group 中断
    ./中断/: zhongduan.c zhongduan.h
